# Repository MichielVanwelsenaere/HomeAutomation.ModbusRtuSensorHub

File README.md:

# Modbus RTU Sensor Hub

----------------------------

:rotating_light: This project is not yet in V1.0 state and is to be considered a work in progress. A release will be created when everything is working as expected.

----------------------------

This PCB with limited footprint is designed to provide a robust and versitale sensor hub using Modbus RTU over RS485. 

# PCB

## General
PCB measurements: ca 32mm x 30.5mm x 11mm

PCB Front                   | PCB Back
:--------------------------:|:-------------------------:
  |  

## Microcontroller
The sensor hub leverages the very capable ATtiny3216 (arduino compatible!).

- 32Kb flash, 2k SRAM - that's the same as an ATmega328p!
- 17 available I/O pins
- 8 PWM pins (6 on TCA0, 2 on TCD0) with 8-bit resolution.
- Servo, Tone, Serial, SPI and Wire (I2C) support "just works"
- 2 Type B timers - so Servo and Tone can both be used simultaneously, or one or both can be taken over for input capture, periodic interrupt, or other functionality.
- DAC output (just do analogWrite() on the DAC pin - voltage is between 0V and the DAC reference voltage, which can be set with setDACReference() ).
- 11 analog inputs, referenced to Vcc, external reference, or one of the 5 built-in analog references.
Internal clock at up to 20MHz at 5v, up to 10MHz at 3.3v

## Capabilities 

- wide range of allowed power supply voltage: 7-30V
- onboard convertor for 3.3V power supply (300mA max)
- onboard convertor for 5V power supply (1.5A max, board power consumption not included)
- two dedicated RS485 connector for leveraging Modbus RTU (bus in and out)
- dedicated 1-Wire connector
- dedicated UPDI connector for programming the board
- dedicated SPI connector
- dedicated I²C connector
- 2 remaining digital pins
- 4 remaining digital/analog pins

# Getting started

- [Required Soldering Materials](./docs/Required-Soldering-Materials.md)
- [BOM (Bill Of Materials)](./docs/BOM.md)
- [Ordering the PCBs](./docs/Ordering-the-PCBs.md)
- [Soldering the PCBs](./docs/Soldering-the-PCBs.md)
- [Building an UPDI programmer](https://www.electronics-lab.com/project/getting-started-with-the-new-attiny-chips-programming-the-microchips-0-series-and-1-series-attiny-with-the-arduino-ide/)
- [Programming](./docs/Programming.md)

# Example projects

- [Blink](./docs/Example-projects/Blink/Blink.md)
- [BlinkAll](./docs/Example-projects/BlinkAll/BlinkAll.md)
- [ModbusRTU StaticValue](./docs/Example-projects/ModbusRTU_StaticValue/ModbusRTU_StaticValue.md)
- [ModbusRTU DS18B20](./docs/Example-projects/ModbusRTU_DS18B20/ModbusRTU_DS18B20.md)

## KiCad design src/ModbusRtuSensorHub.kicad_pcb

Parts:
1-Wire1: Conn_01x03; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal
C1, C2, C3: 100u; C_1206_3216Metric
C4: 100u; CP_Elec_6.3x7.7
D1: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1: Conn_01x9; PinHeader_1x09_P2.54mm_Vertical
I²C1: Conn_01x04; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
LDO1: LD1086DT50TR; TO-252-2
LDO2: MIC5504-3.3YM5; SOT-23-5
R1: 300; R_1206_3216Metric
R2: 4.7k; R_1206_3216Metric
R3: 120; R_1206_3216Metric
R4, R5, R6, R7, R8: 10k; R_1206_3216Metric
RS485: Conn_01x04; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
SPI1: Conn_01x06; JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal
U1: ATtiny3216-S; SOIC-20W_7.5x12.8mm_P1.27mm
U2: MAX1487CSA+T; SOIC127P600X175-8N
UPDI1: Conn_01x03; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal

Connections:
/3.3V: C2.1, H1.3, LDO2.5 (VOUT), SPI1.3
/5V: 1-Wire1.2, C1.1, C3.1, H1.2, I²C1.2, LDO1.2 (OUT), LDO2.1 (VIN), R4.1, R6.1, R7.1, R8.1, SPI1.2, U1.1 (VCC), U2.8, UPDI1.2
/24V: C4.1, LDO1.3 (IN), RS485.4
/A: R3.1, R4.2, RS485.2, U2.6
/B: R3.2, R5.2, RS485.3, U2.7
/GND: 1-Wire1.1, C1.2, C2.2, C3.2, C4.2, D1.1 (K), H1.1, I²C1.1, LDO1.1 (ADJ/GND), LDO2.2 (GND), R5.1, RS485.1, SPI1.1, U1.20 (GND), U2.5, UPDI1.1
/MISO: SPI1.5, U1.18 (PA2)
/MOSI: SPI1.4, U1.17 (PA1)
/PA4: H1.6, U1.2 (PA4)
/PA5: H1.5, U1.3 (PA5)
/PA6: H1.4, U1.4 (PA6)
/PA7: 1-Wire1.3, U1.5 (PA7)
/PB4: R8.2, U1.7 (PB4), U2.2, U2.3
/PB5: H1.7, U1.6 (PB5)
/PC2: H1.9, U1.14 (PC2)
/PC3: H1.8, U1.15 (PC3)
/RST: R2.1, U1.16 (~RESET~/PA0)
/RX: R6.2, U1.8 (PB3), U2.1
/SCK: SPI1.6, U1.19 (PA3)
/SCL: I²C1.3, U1.11 (PB0)
/SDA: I²C1.4, U1.10 (PB1)
/TX: R7.2, U1.9 (PB2), U2.4
unnamed: D1.2 (A), R1.2
unnamed: LDO2.3 (EN), U1.13 (PC1)
unnamed: R1.1, U1.12 (PC0)
unnamed: R2.2, UPDI1.3

Board: 2 copper layers, 30.7 x 34.3 mm, 23 parts (10 on the bottom side), 26 nets.

## KiCad design RS485-Modbus-Tiny-Sensor-Module.kicad_pcb

Parts:
1-Wire1: Conn_01x03; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal
C1, C2, C3: 100u; C_1206_3216Metric
C4: 100u; CP_Elec_6.3x7.7
D1: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
I²C1: Conn_01x04; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
LDO1: LD1086DT50TR; TO-252-2
LDO2: MIC5504-3.3YM5; SOT-23-5
R1: 300; R_1206_3216Metric
R2: 4.7k; R_1206_3216Metric
RS485, RS485_2: Conn_01x04; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
SPI1: Conn_01x06; JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal
U2: ATtiny3216-S; SOIC-20W_7.5x12.8mm_P1.27mm
UPDI1: Conn_01x03; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal

Connections:
/3.3V: C2.1, H1.3, LDO2.5 (VOUT), SPI1.3
/5V: 1-Wire1.2, C1.1, C3.1, H1.2, I²C1.2, LDO1.2 (OUT), LDO2.1 (VIN), SPI1.2, U2.1 (VCC), UPDI1.2
/24V: C4.1, LDO1.3 (IN), RS485.2, RS485_2.2
/GND: 1-Wire1.1, C1.2, C2.2, C3.2, C4.2, D1.1 (K), H1.1, I²C1.1, LDO1.1 (ADJ/GND), LDO2.2 (GND), RS485.1, RS485_2.1, SPI1.1, U2.20 (GND), UPDI1.1
/MISO: SPI1.5, U2.18 (PA2)
/MOSI: SPI1.4, U2.17 (PA1)
/PA4: H1.6, U2.2 (PA4)
/PA5: H1.5, U2.3 (PA5)
/PA6: H1.4, U2.4 (PA6)
/PA7: 1-Wire1.3, U2.5 (PA7)
/PB4: H1.8, U2.7 (PB4)
/PB5: H1.7, U2.6 (PB5)
/PC2: H1.10, U2.14 (PC2)
/PC3: H1.9, U2.15 (PC3)
/RST: R2.1, U2.16 (~RESET~/PA0)
/RX: RS485.3, RS485_2.3, U2.8 (PB3)
/SCK: SPI1.6, U2.19 (PA3)
/SCL: I²C1.3, U2.11 (PB0)
/SDA: I²C1.4, U2.10 (PB1)
/TX: RS485.4, RS485_2.4, U2.9 (PB2)
unnamed: D1.2 (A), R1.2
unnamed: LDO2.3 (EN), U2.13 (PC1)
unnamed: R1.1, U2.12 (PC0)
unnamed: R2.2, UPDI1.3

Board: 2 copper layers, 30.5 x 31.8 mm, 17 parts (5 on the bottom side), 24 nets.

## Commit log

2020-03-28 Add files via upload
    Adding KiCad project to the branch
2020-03-28 Add files via upload
    Changed JST connection to smallest + fix connection to 3.3 V
2020-03-29 Add files via upload
    Added 24V LDO + cleaned layout + added autoreset
2020-03-30 Add files via upload
    Finished layout prototype + added extra JST
2020-04-01 Add files via upload
    Added BOM + .zip file that contains files for production of PCB
2020-04-02 updating BOM with aliExpress links
2020-04-07 Add files via upload
    Checked BOM
2020-05-14 Add files via upload
    PCB V1.0
2020-08-20 reshaping project
2020-08-20 still reshaping project
2020-08-20 adding pcb images
2020-08-20 updating image back
2020-08-20 working on main readme
2020-08-20 working on creating basic docs
2020-08-28 staging work, bom wip
2020-09-01 completing BOM
2020-09-01 updating required soldering materials
2020-09-01 working with zip for output and adding content on ordering the pcb docs page
2020-09-02 completing required soldering materials
2020-09-03 adding first version feather diagram
2020-09-03 minor update on docs
2020-09-04 minor readme update
2020-09-04 pushing updated images
2020-09-04 minor typo updates
2020-09-04 correcting some collors on the featherdiagram
2020-09-04 minor update in featherdiagram
2020-09-21 updating BOM
2020-09-22 update feather diagram
2020-09-23 adding more content on multiple levels
2020-09-23 fixing broking link to programming
2020-09-23 minor update to blink.ino
2020-09-23 fixing broken links
2020-09-24 Add Gitter badge
2020-09-24 removing gitter link
2020-09-24 adding .github folder
2020-09-24 running PR action always on master for testing
2020-09-24 building all samples in PR workflow, wip
2020-09-24 correction in workflow pr syntax
2020-09-24 building specifically for attiny3216 in PR workflow
2020-09-24 only running pull request workflow on PR
2020-10-06 adding rotating light indicating project is a wip
2020-10-13 expanding pipeline to build project with custom library
2020-10-13 building all sketches as well on push to master
2020-10-13 reverting change in pipeline
2020-10-18 updated pcb with onboard transciever
2020-10-18 updating PCB images
2020-10-18 updating draw.io and related files
2020-10-18 minor finetuning on images
2020-10-18 updated BOM to new PCB
2020-10-18 updating featherdiagram
2020-10-18 updating remaining headers in readme
2020-10-25 working on arduino samples
2020-12-15 updating docs on soldering order
2022-01-08 latest version
